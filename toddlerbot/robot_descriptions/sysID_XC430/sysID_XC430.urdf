Commit message: Optimize with all the data

File: toddlerbot/robot_descriptions/sysID_XC430/sysID_XC430.urdf (robot description, URDF)
Before this commit: robot sysID_XC430, 2 links, 1 joints
Links:
- link arm_430: mass 0.37449999999999994404 -> 0.09449999999999994404
